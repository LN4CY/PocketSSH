## sdkconfig.defaults
```kconfig
# PocketSSH ESP-IDF Defaults
CONFIG_ESP_SYSTEM_EVENT_TASK_STACK_SIZE=4096
CONFIG_SYSTEM_EVENT_TASK_STACK_SIZE=4096
```
